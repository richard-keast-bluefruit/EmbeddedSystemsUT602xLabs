# Keil uVision project Lab5.uvproj, settings and files
target FunctionsInC (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: FunctionsInC
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;..\Source\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s UART.c main.cpp Lab5.cpp LaunchPad.cpp
    ../Source/: GraderSerialIO.cpp
  group Object code
    ./: texas.o
