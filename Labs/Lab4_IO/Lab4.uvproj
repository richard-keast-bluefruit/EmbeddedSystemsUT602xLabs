# Keil uVision project Lab4.uvproj, settings and files
target IO (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: IO
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR __cplusplus
  c include: ..\..\Source;..\..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.cpp startup.s LaunchPad.cpp Lab4.cpp
    ../Source/: LaunchPadSwitch.cpp LaunchPadRGBLED.cpp
  group Object code
    ./: texas.o
  group Headers
    ../: tm4c123gh6pm.h
    ../Source/: RGBLEDInterface.h SwitchInterface.h LaunchPadSwitch.h LaunchPadRGBLED.h LaunchPadSwitches.h
    ./: Lab4.h
