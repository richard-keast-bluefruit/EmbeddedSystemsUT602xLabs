# Keil uVision project BasicUART.uvproj, settings and files
target BasicUART (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: BasicUART
  c flags: Optim=1
  c include: E:\Keil\ARM\ARMCC\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group C
    ./: startup_TM4C123.s LED.c PLL.c UART.c
  group CPP
    ./: Main.cpp
